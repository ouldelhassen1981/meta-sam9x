FILESEXTRAPATHS:prepend:sam9x60 := "${THISDIR}/files:"

