FILESEXTRAPATHS:prepend := "${THISDIR}/${P}:"

